# Keil uVision project ThreadCreation.uvprojx, settings and files
target N32WB452 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB452REQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.3
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ThreadCreation +hex
  AfterMake: fromelf --bin --output=.\bin\ThreadCreation.bin .\Objects\ThreadCreation.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc;..\..\..\..\..\..\middlewares\rt-thread\include;..\..\DeviceDrivers\inc;..\..\DeviceDrivers\uart\inc;..\..\DeviceDrivers\gpio\inc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\drivers;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\ipc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_gpio.c n32wb452_rcc.c n32wb452_usart.c n32wb452_exti.c
  group RT_Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: cpuport.c context_rvds.S
  group DOC
    ../: readme.txt
  group USER
    ../src/: n32wb452_it.c board.c main.c
  group Drivers
    ../../DeviceDrivers/gpio/src/: drv_gpio.c
    ../../DeviceDrivers/uart/src/: drv_usart.c
  group Device_Drivers
    ../../../../../../middlewares/rt-thread/components/drivers/serial/: serial.c
    ../../../../../../middlewares/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../middlewares/rt-thread/components/drivers/src/: completion.c
