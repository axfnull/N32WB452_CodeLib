# IAR project Finish.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32WB452RE Nations N32WB452RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32WB452; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc; ..\inc; ..\..\DeviceDrivers\uart\inc; ..\..\DeviceDrivers\inc; ..\..\..\..\..\..\middlewares\rt-thread\include; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\drivers; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\ipc; ..\..\DeviceDrivers\gpio\inc; ..\..\..\..\..\..\middlewares\rt-thread\components\finsh
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Finish.bin
  ILINK.IlinkOutputFile: Finish.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_iar.S cpuport.c
  group Device_Derivers
    ../../DeviceDrivers/gpio/src/: drv_gpio.c
    ../../DeviceDrivers/uart/src/: drv_usart.c
  group Dirvers
    ../../../../../../middlewares/rt-thread/components/drivers/src/: completion.c
    ../../../../../../middlewares/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../middlewares/rt-thread/components/drivers/serial/: serial.c
  group DOC
    ../: readme.txt
  group Finish
    ../../../../../../middlewares/rt-thread/components/finsh/: cmd.c finsh.h finsh_api.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_file.c shell.c shell.h symbol.c
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_exti.c n32wb452_gpio.c n32wb452_rcc.c n32wb452_usart.c
  group RT_Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452_EWARM.s
  group USER
    ../src/: board.c main.c n32wb452_it.c
