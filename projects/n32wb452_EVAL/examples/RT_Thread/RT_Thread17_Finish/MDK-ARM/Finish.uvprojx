# Keil uVision project Finish.uvprojx, settings and files
target N32WB452 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB452REQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.3
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Finish +hex
  AfterMake: fromelf --bin --output=.\bin\Finish.bin .\Objects\Finish.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB45W, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc;..\..\..\..\..\..\middlewares\rt-thread\include;..\..\DeviceDrivers\inc;..\..\DeviceDrivers\gpio\inc;..\..\DeviceDrivers\uart\inc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\drivers;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\ipc;..\..\..\..\..\..\middlewares\rt-thread\components\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: n32wb452_gpio.c n32wb452_rcc.c n32wb452_exti.c n32wb452_usart.c misc.c
  group USER
    ../src/: main.c board.c n32wb452_it.c
  group RT_Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c components.c cpu.c signal.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_rvds.S cpuport.c
  group DOC
    ../: readme.txt
  group DeviceDrivers
    ../../DeviceDrivers/gpio/src/: drv_gpio.c
    ../../DeviceDrivers/uart/src/: drv_usart.c
  group Drivers
    ../../../../../../middlewares/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../middlewares/rt-thread/components/drivers/serial/: serial.c
    ../../../../../../middlewares/rt-thread/components/drivers/src/: completion.c
  group Finish
    ../../../../../../middlewares/rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
