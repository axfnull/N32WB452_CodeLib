# IAR project SPI_DEVICE_REGISTER.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32WB452RE Nations N32WB452RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32WB452; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc; ..\inc; ..\..\DeviceDrivers\uart\inc; ..\..\DeviceDrivers\inc; ..\..\..\..\..\..\middlewares\rt-thread\include; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\drivers; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\ipc; ..\..\DeviceDrivers\gpio\inc; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\spi; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\spi\sfud\inc; ..\..\DeviceDrivers\spi\inc; ..\..\..\..\..\..\middlewares\rt-thread\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_DEVICE_REGISTER.bin
  ILINK.IlinkOutputFile: SPI_DEVICE_REGISTER.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_iar.S cpuport.c
  group Device_Derivers
    ../../DeviceDrivers/gpio/src/: drv_gpio.c
    ../../DeviceDrivers/spi/src/: drv_spi.c
    ../../DeviceDrivers/uart/src/: drv_usart.c
  group Dirvers
    ../../../../../../middlewares/rt-thread/components/drivers/src/: completion.c
    ../../../../../../middlewares/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../middlewares/rt-thread/components/drivers/serial/: serial.c
    ../../../../../../middlewares/rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../../../../middlewares/rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_exti.c n32wb452_gpio.c n32wb452_rcc.c n32wb452_spi.c n32wb452_usart.c
  group RT_Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452_EWARM.s
  group USER
    ../src/: board.c main.c n32wb452_it.c spi_flash_w25q.c
