# Keil uVision project ota_boot.uvprojx, settings and files
target ota_boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32WB452CEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.2
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ble_ota
  AfterMake: fromelf --bin --output .\ble_ota.bin .\Objects\ble_ota.axf
  c flags: uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: N32WB452, USE_STDPERIPH_DRIVER,N32WB452_BT_API,BD_RTC_USE_LSI
  c misc: --wchar32
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc;..\inc;..\src\bsp;..\src\api\inc;..\..\..\..\bsp\inc;..\src\ota\;..\src\ota\crc16;..\src\ota\encrypt;..\src\ota\sha1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_gpio.c n32wb452_rcc.c n32wb452_tim.c n32wb452_spi.c n32wb452_flash.c n32wb452_usart.c
  group USER
    ../src/: main.c n32wb452_it.c n32wb452_w25qxx.c
    ../src/api/src/: n32wb452_flash_interface.c
  group BSP
    ../../../../bsp/src/: log.c
    ../src/bsp/: bsp_spi.c
  group OTA
    ../src/ota/crc16/: CRC16.c
    ../src/ota/: n32wb452_ota_iap.c n32wb452_ota_upgrade.c
  group DOC
    ../: readme.txt
