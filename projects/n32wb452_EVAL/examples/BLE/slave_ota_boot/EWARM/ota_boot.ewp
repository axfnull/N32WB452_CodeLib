# IAR project ota_boot.ewp, settings and files
configuration ota_boot_16bit (ARM, debug)
  General.OGChipSelectEditMenu: N32WB452LE Nations N32WB452LE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32WB452; USE_STDPERIPH_DRIVER; N32WB452_BT_API; BD_RTC_USE_LSI; _DLIB_FILE_DESCRIPTOR; __IAR_ARM
  ICCARM.CCIncludePath2: ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32wb452_std_periph_driver/inc; ../inc; ../src/bsp; ../src/api/inc; ../../../../bsp/inc; ../src/ota/; ../src/ota/crc16; ../src/ota/encrypt; ../src/ota/sha1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ota_boot.srec
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../src/bsp/: bsp_spi.c
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_flash.c n32wb452_gpio.c n32wb452_rcc.c n32wb452_spi.c n32wb452_tim.c n32wb452_usart.c
  group OTA
    ../src/ota/crc16/: CRC16.c
    ../src/ota/: n32wb452_ota_iap.c n32wb452_ota_upgrade.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452_EWARM.s
  group USER
    ../src/: main.c n32wb452_it.c n32wb452_w25qxx.c
    ../src/api/src/: n32wb452_flash_interface.c
