# IAR project slave_ota_app.ewp, settings and files
configuration ota_app_16bit (ARM, debug)
  General.OGChipSelectEditMenu: N32WB452LE Nations N32WB452LE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32WB452; USE_STDPERIPH_DRIVER; N32WB452_BT_API; BD_RTC_USE_LSI; BLE_OTA_WRITE_CHAR_EN; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32wb452_std_periph_driver/inc; ../../../../../../firmware/n32wb452_ble_driver/inc; ../../../../../../firmware/n32wb452_ble_driver/btapi/inc; ../../../../../../firmware/n32wb452_ble_driver/profile/inc; ../../../../../../firmware/n32wb452_ble_driver/platform/inc; ../../../../../../firmware/n32wb452_ble_driver; ..\inc; ../src/bsp; ../src/api/inc; ../../../../bsp/inc; ../src/ota/; ../src/ota/crc16; ../src/ota/encrypt; ../src/ota/sha1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ble_ota.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: n32wb452_ota_app.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\firmware\n32wb452_ble_driver\lib\IAR\host.a; ..\..\..\..\..\..\firmware\n32wb452_ble_driver\lib\IAR\n32wb452_ble.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../src/bsp/: bsp_spi.c bsp_timer.c
    ../../../../bsp/src/: log.c
  group BT_API
    ../../../../../../firmware/n32wb452_ble_driver/: n32wb452_ble_api.c
    ../src/api/src/: n32wb452_data_fifo.c
  group BT_PLATFORM
    ../../../../../../firmware/n32wb452_ble_driver/platform/: Eif_debug.c Eif_flash.c Eif_timer.c Interface.c
  group BT_PROFILE
    ../../../../../../firmware/n32wb452_ble_driver/profile/: app.c app_batt.c app_sec.c app_task.c app_user.c bass.c bass_task.c prf.c prf_utils.c user.c user_task.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_adc.c n32wb452_bkp.c n32wb452_dbg.c n32wb452_exti.c n32wb452_flash.c n32wb452_gpio.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_rtc.c n32wb452_spi.c n32wb452_tim.c n32wb452_usart.c
  group OTA
    ../src/ota/encrypt/: ble_encrypt_interface.c encrypt_app_interface.c SecuritySM4.c sm4.c
    ../src/ota/crc16/: CRC16.c
    ../src/ota/: n32wb452_ble_ota_api.c n32wb452_ble_protocol.c n32wb452_ota_iap.c n32wb452_ota_upgrade.c
    ../src/ota/sha1/: sha1.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452_EWARM.s
  group USER
    ../src/: main.c n32wb452_it.c n32wb452_w25qxx.c
