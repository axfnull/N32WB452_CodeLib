<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\slave_ota_app.ewp</path>
  </project>
  <batchBuild/>
</workspace>
