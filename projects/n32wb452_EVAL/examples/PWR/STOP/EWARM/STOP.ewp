# IAR project STOP.ewp, settings and files
configuration N32WB452 (ARM, debug)
  General.OGChipSelectEditMenu: N32WB452RE Nations N32WB452RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32WB452; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32wb452_std_periph_driver/inc; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/CMSIS/core; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STOP.sim
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32WB452\N32WB452xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_adc.c n32wb452_bkp.c n32wb452_can.c n32wb452_crc.c n32wb452_dac.c n32wb452_dbg.c n32wb452_dma.c n32wb452_dvp.c n32wb452_exti.c n32wb452_flash.c n32wb452_gpio.c n32wb452_i2c.c n32wb452_iwdg.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_rtc.c n32wb452_spi.c n32wb452_tim.c n32wb452_usart.c n32wb452_wwdg.c
  group LOG
    ../../../../bsp/src/: log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452_EWARM.s
  group USER
    ../src/: main.c n32wb452_it.c User_Key_Config.c User_LED_Config.c
