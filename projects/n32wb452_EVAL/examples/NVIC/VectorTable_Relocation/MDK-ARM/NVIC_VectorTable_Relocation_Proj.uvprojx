# Keil uVision project NVIC_VectorTable_Relocation_Proj.uvprojx, settings and files
target N32WB452 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32WB452LEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.2
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NVIC_VectorTable_Relocation_Proj +hex
  AfterMake: fromelf --bin --output=.\bin\NVIC_VectorTable_Relocation_Proj.bin .\Objects\NVIC_VectorTable_Relocation_Proj.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_adc.c n32wb452_bkp.c n32wb452_can.c n32wb452_crc.c n32wb452_dac.c n32wb452_dbg.c n32wb452_dma.c n32wb452_dvp.c n32wb452_exti.c n32wb452_flash.c n32wb452_gpio.c n32wb452_i2c.c n32wb452_iwdg.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_rtc.c n32wb452_spi.c n32wb452_tim.c n32wb452_usart.c n32wb452_wwdg.c
  group BSP
    ../../../../bsp/src/: log.c
  group USER
    ../src/: main.c n32wb452_it.c
  group DOC
    ../: readme.txt
target N32WB452_SRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32WB452LEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.2
  cpu: as above
  output: NVIC_VectorTable_Relocation_Proj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER, VECT_TAB_SRAM
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
