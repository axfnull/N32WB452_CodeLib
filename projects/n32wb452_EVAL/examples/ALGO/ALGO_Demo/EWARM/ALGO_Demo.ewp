# IAR project ALGO_Demo.ewp, settings and files
configuration N32WB452 (ARM, debug)
  General.OGChipSelectEditMenu: N32WB452LE Nations N32WB452LE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32WB452; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; __IAR_ARM
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32wb452_std_periph_driver/inc; ../../../../bsp/inc; ../../../../../../firmware/n32wb452_algo_lib/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ALGO_Demo.srec
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\firmware\n32wb452_algo_lib\lib\n32wb452_aes.lib; ..\..\..\..\..\..\firmware\n32wb452_algo_lib\lib\n32wb452_algo_common.lib; ..\..\..\..\..\..\firmware\n32wb452_algo_lib\lib\n32wb452_des.lib; ..\..\..\..\..\..\firmware\n32wb452_algo_lib\lib\n32wb452_hash.lib; ..\..\..\..\..\..\firmware\n32wb452_algo_lib\lib\n32wb452_rng.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ALGO
    ../../../../../../firmware/n32wb452_algo_lib/lib/: n32wb452_aes.lib n32wb452_algo_common.lib n32wb452_des.lib n32wb452_hash.lib n32wb452_rng.lib
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_flash.c n32wb452_gpio.c n32wb452_rcc.c n32wb452_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452_EWARM.s
  group USER
    ../src/: main.c n32wb452_it.c
