# Keil uVision project RCC_ClockConfig.uvprojx, settings and files
target N32WB452 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: N32WB452LEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RCC_ClockConfig +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER,SYSCLK_SRC=SYSCLK_USE_HSE_PLL,SYSCLK_FREQ=144000000
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_flash.c n32wb452_gpio.c n32wb452_rcc.c n32wb452_usart.c
  group USER
    ../src/: main.c n32wb452_it.c
  group BSP
    ../../../../bsp/src/: log.c
