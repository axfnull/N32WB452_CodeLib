# IAR project CAN_Tx_Rx.ewp, settings and files
configuration n32wb452 (ARM, debug)
  General.OGChipSelectEditMenu: N32WB452LE Nations N32WB452LE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32WB452; USE_STDPERIPH_DRIVER; SYSCLK_FREQ=144000000
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CAN_Tx_Rx.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_bkp.c n32wb452_can.c n32wb452_dbg.c n32wb452_gpio.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_rtc.c n32wb452_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452_EWARM.s
  group USER
    ../src/: main.c n32wb452_it.c User_Can_Config.c User_LED_Config.c User_Systick_Config.c User_Usart_Config.c
