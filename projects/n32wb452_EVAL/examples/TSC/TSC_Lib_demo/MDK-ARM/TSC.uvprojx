# Keil uVision project TSC.uvprojx, settings and files
target N32WB452 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32WB452LEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.3
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TSC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER,BD_RTC_USE_LSI
  c misc: --wchar32
  c include: ..\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc;..\..\..\..\..\..\firmware\CMSIS\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\TSC_Lib.sct
  group Startup
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group Driver
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_bkp.c n32wb452_dma.c n32wb452_exti.c n32wb452_flash.c n32wb452_gpio.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_rtc.c n32wb452_tim.c n32wb452_tsc.c n32wb452_usart.c n32wb452_dbg.c
  group User
    ../src/: main.c bsp_usart.c bsp_gpio.c bsp_it.c bsp_timer.c bsp_tsc.c rtc_hal.c
    ../../../../../../firmware/n32wb452_std_periph_driver/inc/: n32xx_tsc_alg_api.h n32xx_tsc_alg_api.lib
  group DOC
    ../: readme.txt
