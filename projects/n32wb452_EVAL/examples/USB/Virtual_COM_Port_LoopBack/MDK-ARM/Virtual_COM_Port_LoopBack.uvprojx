# Keil uVision project Virtual_COM_Port_LoopBack.uvprojx, settings and files
target N32WB452 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB452LEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.3
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Virtual_COM_Port_LoopBack
  AfterMake: fromelf --bin --output=.\bin\Virtual_COM_Port_LoopBack.bin .\Objects\Virtual_COM_Port_LoopBack.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT=1
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc;..\..\..\..\..\..\firmware\n32wb452_usbfs_driver\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_exti.c n32wb452_gpio.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_usart.c
  group USER
    ../src/: hw_config.c main.c n32wb452_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group n32wb452_usbfs_driver
    ../../../../../../firmware/n32wb452_usbfs_driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group DOC
    ../: readme.txt
